# Keil uVision project emptyProjectStm32F103C8.uvprojx, settings and files
target ROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emptyProjectStm32F103C8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\Inc;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Src/: main.c adc_test.c i2c_test.c
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: emptyProjectStm32F103C8
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, VECT_TAB_SRAM
  c include: .\Inc;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x20000000 size 0x2ffc
  memory RVCT9: RAM 0x20003000 size 0x1000
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
